require xen-openxt-amd-laptops.inc
