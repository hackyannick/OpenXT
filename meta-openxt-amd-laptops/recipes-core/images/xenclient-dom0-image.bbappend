IMAGE_INSTALL_append = " \
    linux-firmware-amdgpu-renoir \
    linux-firmware-amdgpu-yellow-carp \
    linux-firmware-amd-ucode \
    linux-firmware-cirrus-cs35l41 \
"
