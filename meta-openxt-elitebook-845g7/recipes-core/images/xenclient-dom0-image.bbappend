IMAGE_INSTALL_append = " \
    linux-firmware-amdgpu-renoir \
    linux-firmware-amd-ucode \
"
