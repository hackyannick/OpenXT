IMAGE_INSTALL_append = " \
    linux-firmware-rtl8168 \
"
